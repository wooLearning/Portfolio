# Keil uVision project ma_project_dj.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: ma_project_dj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x30000000 size 0x20000000
  scatter file: .\Objects\ma_project_dj.sct
  group source files
    ./source files/: main.c find_IDAT.c convertGray.c countRed.s convertGray.s convertReverse.s main_reallo.c reAllocation.c convertReverseRel.s countRedRel.s convertGrayRel.s isSame.c
  group header files
    ./source files/: convertGray.h find_IDAT.h reAllocation.h isSame.h
  group object files
    ./source files/: startup.o serial.o
